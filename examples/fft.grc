options:
  parameters:
    author: gvanhoy
    generate_options: qt_gui
    id: fft
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '512'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: '512'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '512'
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (np.random.randn(512*1000) + 1j*np.random.randn(512*1000)).tolist()
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '512'
    x_start: '0'
    x_step: '1.0'
    ymax: '40'
    ymin: '0'
  states: {}
- name: torchdsp_fft_vcc_0
  id: torchdsp_fft_vcc
  parameters:
    device_num: '0'
    fft_len: '512'
  states: {}
- name: torchdsp_fir_filter_ccc_0
  id: torchdsp_fir_filter_ccc
  parameters:
    decim_rate: '1'
    device_num: '0'
    taps: firdes.low_pass_2(1.0, 1.0, .25, .125, 80)
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', torchdsp_fft_vcc_0, '0']
- [blocks_vector_source_x_0, '0', torchdsp_fir_filter_ccc_0, '0']
- [torchdsp_fft_vcc_0, '0', blocks_complex_to_mag_squared_0, '0']
- [torchdsp_fir_filter_ccc_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.2.0-33-gbb196fea
