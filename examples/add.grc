options:
  parameters:
    generate_options: qt_gui
    id: add
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/9
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/4
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: torchdsp_add_cc_0
  id: torchdsp_add_cc
  parameters:
    device_num: '0'
    num_inputs: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', torchdsp_add_cc_0, '0']
- [analog_sig_source_x_0_0, '0', torchdsp_add_cc_0, '1']
- [torchdsp_add_cc_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.2.0-33-gbb196fea
